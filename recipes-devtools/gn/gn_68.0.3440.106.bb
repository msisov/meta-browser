require gn.inc

S = "${WORKDIR}/chromium-${PV}"

SRC_URI = "https://commondatastorage.googleapis.com/chromium-browser-official/chromium-${PV}.tar.xz"

SRC_URI[md5sum] = "45f1c943546c008051ec39df51aa20c0"
SRC_URI[sha256sum] = "7021040635a0a0d47f699bdb22e3ef5c91482e4f51b428d1de3016da95f0e698"

